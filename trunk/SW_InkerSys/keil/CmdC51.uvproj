# Keil uVision project CmdC51.uvproj, settings and files
target Keil_Debug (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CmdC51_V +hex
  AfterMake: ..\HexBin\MoveHexFile.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: KEIL_DEBUG
  c include: ..\code\SysBsp\STC60S2\inc;..\code\SysDebug\comdbg;..\code\SysDebug\debug;..\code\SysApp\inc;..\code\SysUI;..\code\DevDriver\product;..\code\DevDriver\lamp;..\code\DevDriver\Key;..\code\DevDriver\input;..\code\DevDriver\beep;..\code\DevDriver\mbs;..\code\DevDriver\InAdc;..\code\DevDriver\LedSeg
  group SysBsp
    ../code/SysBsp/STC60S2/: STARTUP.A51
    ../code/SysBsp/STC60S2/src/: stc125ca60s2.c eeprom_soc.c watchdog_soc.c adc_soc.c
  group SysDbg
    ../code/SysDebug/debug/: debug.c
    ../code/SysDebug/comdbg/: comdbg.c
  group SysApp
    ../code/SysApp/src/: format.c Version.c license.c runtime.c store.c hearbeat.c main.c
  group SysUI
    ../code/SysUI/: Font.c lcd.c Menu1.c Menu2.c MenuTable.c
  group SysDriver
    ../code/DevDriver/product/: project.c
    ../code/DevDriver/Key/: key.c
    ../code/DevDriver/input/: input.c
    ../code/DevDriver/lamp/: lamp.c
    ../code/DevDriver/beep/: beep.c
    ../code/DevDriver/mbs/: crc.c MbsWp.c MbsReg.c MbsRtu.c
    ../code/DevDriver/InAdc/: InAdc.c
    ../code/DevDriver/LedSeg/: LedSeg.c
target CmdC51 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CmdC51_V +hex
  AfterMake: ..\HexBin\MoveHexFile.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code\SysBsp\STC60S2\inc;..\code\SysDebug\comdbg;..\code\SysDebug\debug;..\code\SysApp\inc;..\code\SysUI;..\code\DevDriver\product;..\code\DevDriver\lamp;..\code\DevDriver\Key;..\code\DevDriver\input;..\code\DevDriver\beep;..\code\DevDriver\mbs
